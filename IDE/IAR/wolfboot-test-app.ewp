# IAR project wolfboot-test-app.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: TARGET_stm32f4; ARCH_ARM; WOLFSSL_USER_SETTINGS; DEBUG_CONSOLE_ASSERT_DISABLE=1; WOLFBOOT_SIGN_ECC256; WOLFBOOT_HASH_SHA256; WOLFSSL_SP_ASM; WOLFSSL_SP_ARM_CORTEX_M_ASM
  ICCARM.CCIncludePath2: ..\..\include; $PROJ_DIR$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: wolfboot-test-app.bin
  ILINK.IlinkOutputFile: wolfboot-test-app.out
  ILINK.IlinkIcfFile: test-app.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group src
    ../../test-app/: app_stm32f4.c led.c system.c timer.c
  group wolfboot
    ../../include/: hal.h image.h
    ../../src/: libwolfboot.c
    ../../hal/: stm32f4.c
    ../../include/wolfboot/: wolfboot.h
