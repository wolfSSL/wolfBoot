<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\wolfboot.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\wolfboot-test-app.ewp</path>
    </project>
    <batchBuild />
</workspace>
