# Keil uVision project wolfBoot.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: wolfBoot +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: __WOLFBOOT WOLFBOOT_SIGN_ECC256 XMALLOC_USER IMAGE_HEADER_SIZE=256 WOLFBOOT_HASH_SHA256 WOLFSSL_USER_SETTINGS WOLFSSL_SP_ASM WOLFSSL_SP_ARM_CORTEX_M_ASM
  c include: ..\..\include;..\..\hal;..\..\lib\wolfssl\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ../../src/: boot_arm.c image.c libwolfboot.c loader.c string.c update_flash.c xmalloc_ecc.c
    ../../include/: hal.h image.h loader.h printf.h spi_drv.h spi_flash.h target.h uart_flash.h user_settings.h
    ../../include/wolfboot/: wolfboot.h
    ../../hal/: stm32f4.c
    ../../lib/wolfssl/wolfcrypt/src/: sp_cortexm.c sp_int.c sha256.c hash.c memory.c wc_port.c ecc.c
    ./: ecc256_pub_key.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.2.2
